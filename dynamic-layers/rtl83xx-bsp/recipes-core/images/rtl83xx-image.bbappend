# Userspace on top of the BSP's flashable squashfs image, identical to the
# initramfs.

require rtl83xx-image-common.inc
