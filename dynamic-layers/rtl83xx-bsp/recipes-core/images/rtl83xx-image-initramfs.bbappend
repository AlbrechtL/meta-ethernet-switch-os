# Userspace on top of the BSP's bootable initramfs. The BSP recipe keeps all of
# the initramfs/EXTRA_IMAGEDEPENDS loop handling; this only adds packages.

require rtl83xx-image-common.inc
